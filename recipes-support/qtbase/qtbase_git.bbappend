PACKAGECONFIG = " \
    release \
    dbus \
    tools \
    libs \
    "

QT_CONFIG_FLAGS += " \
    -no-qpa-platform-guard \
    -no-gui \
    "
